# Keil uVision project gmg12864_v01.uvprojx, settings and files
target GMG12864 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gmg12864_v01 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    $$Device:STM32F103C8$Device/Source/ARM/: startup_stm32f10x_md.s
    ./src/: main.c spi1.c gmg12864.c spi1.h gmg12864.h startup_splash.h adc1_app.c adc1_app.h board_pins.h generator_menu.c generator_menu.h ts_button.c ts_button.h i2c2_soft.c i2c2_soft.h at24c256.c at24c256.h i2c_soft.c i2c_soft.h input.c input.h si5351.c si5351.h uart1.c uart1.h app_config.h app_state.h app_time.h eeprom_startup.c eeprom_startup.h freq_entry.c freq_entry.h lcd_digits_large.c lcd_digits_small.c lcd_text.c radio_control.c radio_control.h text_utils.c text_utils.h ui_frequency.c ui_frequency.h ui_screens.c ui_screens.h ui_smeter.c ui_smeter.h ui_widgets.c ui_widgets.h key_gesture.c key_gesture.h key_layout.c key_layout.h radio_mode.c radio_mode.h radio_vfo.c radio_vfo.h keyboard.c keyboard.h entry_controller.c entry_controller.h frequency_parse.c frequency_parse.h memory_control.c memory_control.h memory_record.c memory_record.h memory_store.c memory_store.h radio_panel.c radio_panel.h scan_control.c scan_control.h uart_config.c boot_audit.c boot_startup.c ui_boot.c eeprom_factory.c service_factory.c ui_service_factory.c service_contrast.c ui_service_contrast.c uart_store.c service_uart.c service_keytest.c ui_service_tools.c service_catalog.c service_control.c service_values.c ui_service.c settings_control.c settings_control.h ui_settings.c ui_settings.h ui_status.c ui_status.h
    ./font/: font_tahoma_8_prop.h font_terminus_15_digi.h font_terminus_10x17_digi.h font_meter_4x6.h font_sw2019_refined_digi.h font_sw2019_half_10x16_digi.h font_status_5x7.h font_terminus_10x19_digi.h font_terminus_7x11_digi.h
software components: CMSIS:CORE 5.5.0
